options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '25000000'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: usrp_sweep_prefill_wait_dialog_0
  id: usrp_sweep_prefill_wait_dialog
  parameters:
    title: USRP Sweep
  states: {}
- name: usrp_sweep_set_time_sink_nsamps_0
  id: usrp_sweep_set_time_sink_nsamps
  parameters:
    time_sink: qtgui_time_sink_x_0
  states: {}
- name: usrp_sweep_usrp_sweep_0
  id: usrp_sweep_usrp_sweep
  parameters:
    antenna: '"RX2"'
    args: '""'
    average_alpha: '0.0025'
    bandwidth: '0'
    buffer_capacity: '1000000'
    fft_size: '2048'
    lo_setup_time: '0.5'
    lock_time: '0.01'
    master_clock: '-1'
    norm_gain: '0.8'
    output_db: 'True'
    overlap: '0.75'
    ref: '""'
    rx_subdev: '""'
    sample_rate: samp_rate
    start_fc: 100e6
    stop_fc: 1000e6
    wire: '""'
  states: {}

connections:
- [usrp_sweep_usrp_sweep_0, '0', qtgui_time_sink_x_0, '0']
- [usrp_sweep_usrp_sweep_0, num_points, usrp_sweep_set_time_sink_nsamps_0, inpair]
- [usrp_sweep_usrp_sweep_0, status, usrp_sweep_prefill_wait_dialog_0, status]

metadata:
  file_format: 1
